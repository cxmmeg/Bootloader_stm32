# IAR project Project.ewp, settings and files
configuration STM3210C-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210C_EVAL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\code\user; ..\code\user\common; ..\code\lib\Library\inc; ..\code\lib\Library; ..\code\lib\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootloader.bin
  ILINK.IlinkOutputFile: STM3210C-EVAL.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL
  group CMSIS
    ../code/lib/Library/: system_stm32f10x.c
  group IAR
    ../code/lib/Library/: startup_stm32f10x_md.s
  group library
    ../code/lib/Library/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../code/user/: cmds.c evbcmds.c flash.c flash.h main.c printk.c stm32f10x_it.c ymodem.c ymodem.h
    ../code/user/common/: comfunc.c comfunc.h stm32serial.c
